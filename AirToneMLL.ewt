<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>BSP</name>
    <file>
      <name>$PROJ_DIR$\BSP\BSP.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BSP\BSP.h</name>
    </file>
  </group>
  <group>
    <name>DRIVER</name>
    <group>
      <name>AIK4637</name>
      <file>
        <name>$PROJ_DIR$\DRIVER\AK4637\AK4637.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\AK4637\AK4637.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\AK4637\AK4637_Register.h</name>
      </file>
    </group>
    <group>
      <name>CC8530</name>
      <file>
        <name>$PROJ_DIR$\DRIVER\CC8530\CC8530.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\CC8530\CC8530.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\CC8530\CC8530_Register.h</name>
      </file>
    </group>
    <group>
      <name>Memory</name>
      <file>
        <name>$PROJ_DIR$\DRIVER\Memory\M25P128.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\Memory\M25P128.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\Memory\MemManage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\Memory\MemManage.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\Memory\UART.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\Memory\UART.h</name>
      </file>
    </group>
    <group>
      <name>OLED</name>
      <file>
        <name>$PROJ_DIR$\DRIVER\OLED\OLED.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\OLED\OLED.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\OLED\OLED_font.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\OLED\OLED_Interface.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\OLED\OLED_Interface.h</name>
      </file>
    </group>
    <group>
      <name>Serial</name>
      <file>
        <name>$PROJ_DIR$\DRIVER\Serial\I2Csim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\DRIVER\Serial\I2Csim.h</name>
      </file>
    </group>
    <group>
      <name>STM8L152C6</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_adc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_aes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_beep.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_clk.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_comp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_dac.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_dma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_exti.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_gpio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_i2c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_irtim.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_itc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_iwdg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_lcd.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_pwr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_rst.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_rtc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_spi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_syscfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_tim1.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_tim2.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_tim3.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_tim4.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_tim5.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_usart.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_wfe.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\inc\stm8l15x_wwdg.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_aes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_beep.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_clk.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_comp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_dac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_exti.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_irtim.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_itc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_iwdg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_lcd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_pwr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_rst.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_syscfg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_tim1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_tim2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_tim3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_tim4.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_tim5.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_usart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_wfe.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\DRIVER\STM8L152C6\src\stm8l15x_wwdg.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\USER\BasicOp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\BasicOp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\MyTypeDef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\stm8l15x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\stm8l15x_it.h</name>
    </file>
  </group>
</project>


