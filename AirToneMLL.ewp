# IAR project AirToneMLL.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: BSP; USER; DRIVER; DRIVER\Memory; DRIVER\AK4637; DRIVER\CC8530; DRIVER\Serial; DRIVER\OLED; DRIVER\STM8L152C6\inc; $PROJ_DIR$|DRIVER\STM8L152C6\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: AirToneMLL.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group BSP
    BSP/: BSP.c BSP.h
  group DRIVER/AIK4637
    DRIVER/AK4637/: AK4637.c AK4637.h AK4637_Register.h
  group DRIVER/CC8530
    DRIVER/CC8530/: CC8530.c CC8530.h CC8530_Register.h
  group DRIVER/Memory
    DRIVER/Memory/: M25P128.c M25P128.h MemManage.c MemManage.h UART.c UART.h
  group DRIVER/OLED
    DRIVER/OLED/: OLED.c OLED.h OLED_font.h OLED_Interface.c OLED_Interface.h
  group DRIVER/Serial
    DRIVER/Serial/: I2Csim.c I2Csim.h
  group DRIVER/STM8L152C6/inc
    DRIVER/STM8L152C6/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h
  group DRIVER/STM8L152C6/src
    DRIVER/STM8L152C6/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group USER
    USER/: BasicOp.c BasicOp.h main.c MyTypeDef.h stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
